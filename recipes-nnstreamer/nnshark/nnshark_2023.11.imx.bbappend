# Include commit fixing dead URL to gstreamer Git submodule
SRCREV = "4ed66906b889e66a6458a1d2692790f64bf1c556"
