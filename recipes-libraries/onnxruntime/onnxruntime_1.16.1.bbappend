SRC_URI += " \
    file://0001-WORKAROUND-Disable-FP16-code-for-ARM64.patch \
"
